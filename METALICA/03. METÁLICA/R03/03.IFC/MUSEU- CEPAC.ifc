Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: MUSEU- CEPAC
Time: 2025-09-03T10:37:21
Written by: BIMServer.center IFC Preprocessor 1.0

# IfcBuildingStorey, Planta
Elevation: 0 m

# IfcBeam: 2xC150X60X17X3([]) (7)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N23/N21) (2xC150X60X17X3([]))
Peça (N22/N21) (2xC150X60X17X3([]))
Peça (N25/N24) (2xC150X60X17X3([]))
Peça (N19/N18) (2xC150X60X17X3([]))
Peça (N17/N15) (2xC150X60X17X3([]))
Peça (N16/N15) (2xC150X60X17X3([]))
Peça (N20/N18) (2xC150X60X17X3([]))

# IfcBeam: C127X50X17X3 (19)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N45/N49) (C127X50X17X3)
Peça (N50/N54) (C127X50X17X3)
Peça (N55/N59) (C127X50X17X3)
Peça (N68/N65) (C127X50X17X3)
Peça (N69/N73) (C127X50X17X3)
Peça (N78/N82) (C127X50X17X3)
Peça (N83/N84) (C127X50X17X3)
Peça (N60/N61) (C127X50X17X3)
Peça (N61/N62) (C127X50X17X3)
Peça (N62/N63) (C127X50X17X3)
Peça (N14/N63) (C127X50X17X3)
Peça (N75/N74) (C127X50X17X3)
Peça (N76/N75) (C127X50X17X3)
Peça (N77/N76) (C127X50X17X3)
Peça (N85/N13) (C127X50X17X3)
Peça (N4/N40) (C127X50X17X3)
Peça (N41/N44) (C127X50X17X3)
Peça (N114/N115) (C127X50X17X3)
Peça (N117/N118) (C127X50X17X3)

# IfcBeam: LF-50x3 (6)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N86/N90) (LF-50x3)
Peça (N91/N95) (LF-50x3)
Peça (N97/N101) (LF-50x3)
Peça (N103/N107) (LF-50x3)
Peça (N111/N108) (LF-50x3)
Peça (N116/N113) (LF-50x3)

# IfcColumn: 2xC150X60X17X3([]) (14)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Name | Length (m)
Peça (N26/N9) (2xC150X60X17X3([])) | 0.2
Peça (N27/N5) (2xC150X60X17X3([])) | 0.2
Peça (N28/N1) (2xC150X60X17X3([])) | 0.2
Peça (N29/N2) (2xC150X60X17X3([])) | 0.6926
Peça (N30/N6) (2xC150X60X17X3([])) | 0.6926
Peça (N31/N10) (2xC150X60X17X3([])) | 0.6926
Peça (N32/N11) (2xC150X60X17X3([])) | 0.8446
Peça (N33/N7) (2xC150X60X17X3([])) | 0.8446
Peça (N34/N3) (2xC150X60X17X3([])) | 0.8446
Peça (N35/N4) (2xC150X60X17X3([])) | 0.352
Peça (N36/N8) (2xC150X60X17X3([])) | 0.352
Peça (N37/N12) (2xC150X60X17X3([])) | 0.352
Peça (N38/N14) (2xC150X60X17X3([])) | 0.99992
Peça (N39/N13) (2xC150X60X17X3([])) | 0.495855

# IfcMember: R 12 (42)
In: Planta
Description: Barra maciça. Aço laminado; Material: A-36 250Mpa
Pset_MemberCommon - LoadBearing: yes
Name
Peça (N12/N42) (R 12)
Peça (N42/N48) (R 12)
Peça (N48/N52) (R 12)
Peça (N52/N58) (R 12)
Peça (N47/N53) (R 12)
Peça (N43/N47) (R 12)
Peça (N8/N43) (R 12)
Peça (N8/N41) (R 12)
Peça (N41/N47) (R 12)
Peça (N47/N51) (R 12)
Peça (N51/N57) (R 12)
Peça (N52/N56) (R 12)
Peça (N46/N52) (R 12)
Peça (N42/N46) (R 12)
Peça (N4/N42) (R 12)
Peça (N66/N61) (R 12)
Peça (N70/N66) (R 12)
Peça (N75/N70) (R 12)
Peça (N79/N75) (R 12)
Peça (N5/N79) (R 12)
Peça (N1/N80) (R 12)
Peça (N80/N76) (R 12)
Peça (N76/N71) (R 12)
Peça (N71/N67) (R 12)
Peça (N67/N62) (R 12)
Peça (N64/N62) (R 12)
Peça (N71/N64) (R 12)
Peça (N74/N71) (R 12)
Peça (N80/N74) (R 12)
Peça (N9/N80) (R 12)
Peça (N5/N81) (R 12)
Peça (N81/N75) (R 12)
Peça (N75/N72) (R 12)
Peça (N72/N66) (R 12)
Peça (N66/N63) (R 12)
Peça (N65/N63) (R 12)
Peça (N72/N65) (R 12)
Peça (N13/N72) (R 12)
Peça (N85/N73) (R 12)
Peça (N73/N64) (R 12)
Peça (N64/N14) (R 12)
Peça (N53/N57) (R 12)
