Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: ACESSO GALPAO MULTIUSO- CEPAC
Time: 2025-09-03T08:47:26
Written by: BIMServer.center IFC Preprocessor 1.0

# IfcBuildingStorey, Planta
Elevation: 0 m

# IfcBeam: 2xC100X50X17X3([]) (10)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N1/N3) (2xC100X50X17X3([]))
Peça (N4/N6) (2xC100X50X17X3([]))
Peça (N7/N9) (2xC100X50X17X3([]))
Peça (N10/N12) (2xC100X50X17X3([]))
Peça (N13/N15) (2xC100X50X17X3([]))
Peça (N15/N38) (2xC100X50X17X3([]))
Peça (N12/N39) (2xC100X50X17X3([]))
Peça (N9/N40) (2xC100X50X17X3([]))
Peça (N6/N41) (2xC100X50X17X3([]))
Peça (N3/N42) (2xC100X50X17X3([]))

# IfcBeam: C127X50X17X3 (12)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N6/N3) (C127X50X17X3)
Peça (N9/N6) (C127X50X17X3)
Peça (N12/N9) (C127X50X17X3)
Peça (N15/N12) (C127X50X17X3)
Peça (N20/N19) (C127X50X17X3)
Peça (N19/N18) (C127X50X17X3)
Peça (N18/N16) (C127X50X17X3)
Peça (N16/N17) (C127X50X17X3)
Peça (N21/N22) (C127X50X17X3)
Peça (N22/N23) (C127X50X17X3)
Peça (N23/N24) (C127X50X17X3)
Peça (N24/N25) (C127X50X17X3)

# IfcBeam: LF-50x3 (8)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N27/N26) (LF-50x3)
Peça (N28/N27) (LF-50x3)
Peça (N30/N29) (LF-50x3)
Peça (N31/N30) (LF-50x3)
Peça (N33/N32) (LF-50x3)
Peça (N34/N33) (LF-50x3)
Peça (N36/N35) (LF-50x3)
Peça (N37/N36) (LF-50x3)

# IfcColumn: 2xC100X50X17X3([]) (10)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Name | Length (m)
Peça (N51/N52) (2xC100X50X17X3([])) | 3.04102
Peça (N2/N3) (2xC100X50X17X3([])) | 3.227
Peça (N49/N50) (2xC100X50X17X3([])) | 3.04102
Peça (N5/N6) (2xC100X50X17X3([])) | 3.227
Peça (N47/N48) (2xC100X50X17X3([])) | 3.04102
Peça (N8/N9) (2xC100X50X17X3([])) | 3.227
Peça (N45/N46) (2xC100X50X17X3([])) | 3.04102
Peça (N11/N12) (2xC100X50X17X3([])) | 3.227
Peça (N43/N44) (2xC100X50X17X3([])) | 3.04102
Peça (N14/N15) (2xC100X50X17X3([])) | 3.227
