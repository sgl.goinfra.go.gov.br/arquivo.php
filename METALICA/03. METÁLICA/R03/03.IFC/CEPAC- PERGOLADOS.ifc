Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: CEPAC- PERGOLADOS
Time: 2025-08-12T11:10:30
Written by: BIMServer.center IFC Preprocessor 1.0

# IfcBuildingStorey, Planta
Elevation: 0 m

# IfcBeam: 2xC100X50X17X3([]) (14)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N6/N12) (2xC100X50X17X3([]))
Peça (N12/N10) (2xC100X50X17X3([]))
Peça (N10/N8) (2xC100X50X17X3([]))
Peça (N2/N8) (2xC100X50X17X3([]))
Peça (N4/N2) (2xC100X50X17X3([]))
Peça (N6/N4) (2xC100X50X17X3([]))
Peça (N4/N10) (2xC100X50X17X3([]))
Peça (N54/N52) (2xC100X50X17X3([]))
Peça (N52/N50) (2xC100X50X17X3([]))
Peça (N76/N78) (2xC100X50X17X3([]))
Peça (N74/N76) (2xC100X50X17X3([]))
Peça (N74/N54) (2xC100X50X17X3([]))
Peça (N78/N50) (2xC100X50X17X3([]))
Peça (N76/N52) (2xC100X50X17X3([]))

# IfcBeam: 2xC50X25X10X2([]) (36)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N13/N22) (2xC50X25X10X2([]))
Peça (N14/N23) (2xC50X25X10X2([]))
Peça (N15/N24) (2xC50X25X10X2([]))
Peça (N16/N25) (2xC50X25X10X2([]))
Peça (N17/N26) (2xC50X25X10X2([]))
Peça (N18/N27) (2xC50X25X10X2([]))
Peça (N19/N28) (2xC50X25X10X2([]))
Peça (N20/N29) (2xC50X25X10X2([]))
Peça (N21/N30) (2xC50X25X10X2([]))
Peça (N31/N40) (2xC50X25X10X2([]))
Peça (N32/N41) (2xC50X25X10X2([]))
Peça (N33/N42) (2xC50X25X10X2([]))
Peça (N34/N43) (2xC50X25X10X2([]))
Peça (N35/N44) (2xC50X25X10X2([]))
Peça (N36/N45) (2xC50X25X10X2([]))
Peça (N37/N46) (2xC50X25X10X2([]))
Peça (N38/N47) (2xC50X25X10X2([]))
Peça (N39/N48) (2xC50X25X10X2([]))
Peça (N96/N55) (2xC50X25X10X2([]))
Peça (N95/N56) (2xC50X25X10X2([]))
Peça (N94/N57) (2xC50X25X10X2([]))
Peça (N93/N58) (2xC50X25X10X2([]))
Peça (N92/N59) (2xC50X25X10X2([]))
Peça (N91/N60) (2xC50X25X10X2([]))
Peça (N90/N61) (2xC50X25X10X2([]))
Peça (N89/N62) (2xC50X25X10X2([]))
Peça (N88/N63) (2xC50X25X10X2([]))
Peça (N87/N64) (2xC50X25X10X2([]))
Peça (N85/N66) (2xC50X25X10X2([]))
Peça (N84/N67) (2xC50X25X10X2([]))
Peça (N83/N68) (2xC50X25X10X2([]))
Peça (N82/N69) (2xC50X25X10X2([]))
Peça (N81/N70) (2xC50X25X10X2([]))
Peça (N80/N71) (2xC50X25X10X2([]))
Peça (N79/N72) (2xC50X25X10X2([]))
Peça (N86/N65) (2xC50X25X10X2([]))

# IfcColumn: 2xC100X50X17X3([]) (12)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Qto_ColumnBaseQuantities - Length: 2.8 m
Name
Peça (N1/N2) (2xC100X50X17X3([]))
Peça (N3/N4) (2xC100X50X17X3([]))
Peça (N5/N6) (2xC100X50X17X3([]))
Peça (N7/N8) (2xC100X50X17X3([]))
Peça (N9/N10) (2xC100X50X17X3([]))
Peça (N11/N12) (2xC100X50X17X3([]))
Peça (N77/N78) (2xC100X50X17X3([]))
Peça (N75/N76) (2xC100X50X17X3([]))
Peça (N73/N74) (2xC100X50X17X3([]))
Peça (N49/N50) (2xC100X50X17X3([]))
Peça (N51/N52) (2xC100X50X17X3([]))
Peça (N53/N54) (2xC100X50X17X3([]))
