Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: CEPAC- CABINES
Time: 2025-08-12T10:56:23
Written by: BIMServer.center IFC Preprocessor 1.0

# IfcBuildingStorey, Planta
Elevation: 0 m

# IfcBeam: 2xLF-60x3([]) (56)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N5/N14) (2xLF-60x3([]))
Peça (N11/N15) (2xLF-60x3([]))
Peça (N10/N16) (2xLF-60x3([]))
Peça (N9/N3) (2xLF-60x3([]))
Peça (N7/N17) (2xLF-60x3([]))
Peça (N13/N18) (2xLF-60x3([]))
Peça (N12/N2) (2xLF-60x3([]))
Peça (N5/N22) (2xLF-60x3([]))
Peça (N31/N23) (2xLF-60x3([]))
Peça (N30/N24) (2xLF-60x3([]))
Peça (N29/N25) (2xLF-60x3([]))
Peça (N28/N26) (2xLF-60x3([]))
Peça (N32/N27) (2xLF-60x3([]))
Peça (N33/N20) (2xLF-60x3([]))
Peça (N49/N40) (2xLF-60x3([]))
Peça (N48/N41) (2xLF-60x3([]))
Peça (N47/N42) (2xLF-60x3([]))
Peça (N45/N43) (2xLF-60x3([]))
Peça (N50/N44) (2xLF-60x3([]))
Peça (N51/N37) (2xLF-60x3([]))
Peça (N64/N56) (2xLF-60x3([]))
Peça (N63/N57) (2xLF-60x3([]))
Peça (N62/N58) (2xLF-60x3([]))
Peça (N61/N59) (2xLF-60x3([]))
Peça (N65/N60) (2xLF-60x3([]))
Peça (N66/N53) (2xLF-60x3([]))
Peça (N82/N73) (2xLF-60x3([]))
Peça (N81/N74) (2xLF-60x3([]))
Peça (N80/N75) (2xLF-60x3([]))
Peça (N78/N76) (2xLF-60x3([]))
Peça (N83/N77) (2xLF-60x3([]))
Peça (N84/N70) (2xLF-60x3([]))
Peça (N97/N89) (2xLF-60x3([]))
Peça (N96/N90) (2xLF-60x3([]))
Peça (N95/N91) (2xLF-60x3([]))
Peça (N94/N92) (2xLF-60x3([]))
Peça (N98/N93) (2xLF-60x3([]))
Peça (N99/N86) (2xLF-60x3([]))
Peça (N100/N105) (2xLF-60x3([]))
Peça (N115/N106) (2xLF-60x3([]))
Peça (N114/N107) (2xLF-60x3([]))
Peça (N113/N108) (2xLF-60x3([]))
Peça (N111/N109) (2xLF-60x3([]))
Peça (N116/N110) (2xLF-60x3([]))
Peça (N117/N103) (2xLF-60x3([]))
Peça (N100/N121) (2xLF-60x3([]))
Peça (N130/N122) (2xLF-60x3([]))
Peça (N129/N123) (2xLF-60x3([]))
Peça (N128/N124) (2xLF-60x3([]))
Peça (N127/N125) (2xLF-60x3([]))
Peça (N131/N126) (2xLF-60x3([]))
Peça (N132/N119) (2xLF-60x3([]))
Peça (N67/N72) (2xLF-60x3([]))
Peça (N67/N88) (2xLF-60x3([]))
Peça (N34/N39) (2xLF-60x3([]))
Peça (N34/N55) (2xLF-60x3([]))

# IfcBeam: C200X75X20X2.3 (6)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N103/N2) (C200X75X20X2.3)
Peça (N108/N3) (C200X75X20X2.3)
Peça (N104/N4) (C200X75X20X2.3)
Peça (N120/N21) (C200X75X20X2.3)
Peça (N124/N25) (C200X75X20X2.3)
Peça (N119/N20) (C200X75X20X2.3)

# IfcBeam: LF-50x3 (24)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N135/N133) (LF-50x3)
Peça (N137/N135) (LF-50x3)
Peça (N138/N136) (LF-50x3)
Peça (N136/N134) (LF-50x3)
Peça (N153/N155) (LF-50x3)
Peça (N151/N153) (LF-50x3)
Peça (N152/N154) (LF-50x3)
Peça (N154/N156) (LF-50x3)
Peça (N159/N157) (LF-50x3)
Peça (N161/N159) (LF-50x3)
Peça (N162/N160) (LF-50x3)
Peça (N160/N158) (LF-50x3)
Peça (N166/N168) (LF-50x3)
Peça (N164/N166) (LF-50x3)
Peça (N165/N167) (LF-50x3)
Peça (N163/N165) (LF-50x3)
Peça (N148/N146) (LF-50x3)
Peça (N150/N148) (LF-50x3)
Peça (N147/N145) (LF-50x3)
Peça (N149/N147) (LF-50x3)
Peça (N142/N144) (LF-50x3)
Peça (N140/N142) (LF-50x3)
Peça (N141/N143) (LF-50x3)
Peça (N139/N141) (LF-50x3)

# IfcBeam: U200X50X4.76 (24)
In: Planta
Description: U dobrado simples. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N1/N2) (U200X50X4.76)
Peça (N5/N7) (U200X50X4.76)
Peça (N7/N6) (U200X50X4.76)
Peça (N1/N20) (U200X50X4.76)
Peça (N28/N5) (U200X50X4.76)
Peça (N19/N28) (U200X50X4.76)
Peça (N35/N37) (U200X50X4.76)
Peça (N34/N45) (U200X50X4.76)
Peça (N45/N36) (U200X50X4.76)
Peça (N35/N53) (U200X50X4.76)
Peça (N61/N34) (U200X50X4.76)
Peça (N52/N61) (U200X50X4.76)
Peça (N68/N70) (U200X50X4.76)
Peça (N67/N78) (U200X50X4.76)
Peça (N78/N69) (U200X50X4.76)
Peça (N68/N86) (U200X50X4.76)
Peça (N94/N67) (U200X50X4.76)
Peça (N85/N94) (U200X50X4.76)
Peça (N101/N103) (U200X50X4.76)
Peça (N100/N111) (U200X50X4.76)
Peça (N111/N102) (U200X50X4.76)
Peça (N101/N119) (U200X50X4.76)
Peça (N127/N100) (U200X50X4.76)
Peça (N118/N127) (U200X50X4.76)

# IfcColumn: 2xC 150x50x15x2.5mm([]) (4)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Qto_ColumnBaseQuantities - Length: 0.2 m
Name
Peça (N8/N5) (2xC 150x50x15x2.5mm([]))
Peça (N46/N34) (2xC 150x50x15x2.5mm([]))
Peça (N79/N67) (2xC 150x50x15x2.5mm([]))
Peça (N112/N100) (2xC 150x50x15x2.5mm([]))

# IfcColumn: 2xLF-60x3([]) (68)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Name | Length (m)
Peça (N5/N1) (2xLF-60x3([])) | 0.5
Peça (N6/N2) (2xLF-60x3([])) | 0.767
Peça (N7/N3) (2xLF-60x3([])) | 0.640964
Peça (N11/N14) (2xLF-60x3([])) | 0.535241
Peça (N10/N15) (2xLF-60x3([])) | 0.570482
Peça (N9/N16) (2xLF-60x3([])) | 0.605723
Peça (N13/N17) (2xLF-60x3([])) | 0.682976
Peça (N12/N18) (2xLF-60x3([])) | 0.724988
Peça (N19/N20) (2xLF-60x3([])) | 0.767
Peça (N28/N25) (2xLF-60x3([])) | 0.640964
Peça (N31/N22) (2xLF-60x3([])) | 0.535241
Peça (N30/N23) (2xLF-60x3([])) | 0.570482
Peça (N29/N24) (2xLF-60x3([])) | 0.605723
Peça (N32/N26) (2xLF-60x3([])) | 0.682976
Peça (N33/N27) (2xLF-60x3([])) | 0.724988
Peça (N34/N35) (2xLF-60x3([])) | 0.5
Peça (N36/N37) (2xLF-60x3([])) | 0.767
Peça (N45/N42) (2xLF-60x3([])) | 0.640964
Peça (N49/N39) (2xLF-60x3([])) | 0.535241
Peça (N48/N40) (2xLF-60x3([])) | 0.570482
Peça (N47/N41) (2xLF-60x3([])) | 0.605723
Peça (N50/N43) (2xLF-60x3([])) | 0.682976
Peça (N51/N44) (2xLF-60x3([])) | 0.724988
Peça (N52/N53) (2xLF-60x3([])) | 0.767
Peça (N61/N58) (2xLF-60x3([])) | 0.640964
Peça (N64/N55) (2xLF-60x3([])) | 0.535241
Peça (N63/N56) (2xLF-60x3([])) | 0.570482
Peça (N62/N57) (2xLF-60x3([])) | 0.605723
Peça (N65/N59) (2xLF-60x3([])) | 0.682976
Peça (N66/N60) (2xLF-60x3([])) | 0.724988
Peça (N67/N68) (2xLF-60x3([])) | 0.5
Peça (N69/N70) (2xLF-60x3([])) | 0.767
Peça (N78/N75) (2xLF-60x3([])) | 0.640964
Peça (N82/N72) (2xLF-60x3([])) | 0.535241
Peça (N81/N73) (2xLF-60x3([])) | 0.570482
Peça (N80/N74) (2xLF-60x3([])) | 0.605723
Peça (N83/N76) (2xLF-60x3([])) | 0.682976
Peça (N84/N77) (2xLF-60x3([])) | 0.724988
Peça (N85/N86) (2xLF-60x3([])) | 0.767
Peça (N94/N91) (2xLF-60x3([])) | 0.640964
Peça (N97/N88) (2xLF-60x3([])) | 0.535241
Peça (N96/N89) (2xLF-60x3([])) | 0.570482
Peça (N95/N90) (2xLF-60x3([])) | 0.605723
Peça (N98/N92) (2xLF-60x3([])) | 0.682976
Peça (N99/N93) (2xLF-60x3([])) | 0.724988
Peça (N100/N101) (2xLF-60x3([])) | 0.5
Peça (N102/N103) (2xLF-60x3([])) | 0.767
Peça (N111/N108) (2xLF-60x3([])) | 0.640964
Peça (N115/N105) (2xLF-60x3([])) | 0.535241
Peça (N114/N106) (2xLF-60x3([])) | 0.570482
Peça (N113/N107) (2xLF-60x3([])) | 0.605723
Peça (N116/N109) (2xLF-60x3([])) | 0.682976
Peça (N117/N110) (2xLF-60x3([])) | 0.724988
Peça (N118/N119) (2xLF-60x3([])) | 0.767
Peça (N127/N124) (2xLF-60x3([])) | 0.640964
Peça (N130/N121) (2xLF-60x3([])) | 0.535241
Peça (N129/N122) (2xLF-60x3([])) | 0.570482
Peça (N128/N123) (2xLF-60x3([])) | 0.605723
Peça (N131/N125) (2xLF-60x3([])) | 0.682976
Peça (N132/N126) (2xLF-60x3([])) | 0.724988
Peça (N169/N170) (2xLF-60x3([])) | 0.26762
Peça (N171/N172) (2xLF-60x3([])) | 0.26762
Peça (N173/N174) (2xLF-60x3([])) | 0.26762
Peça (N175/N176) (2xLF-60x3([])) | 0.26762
Peça (N177/N178) (2xLF-60x3([])) | 0.26762
Peça (N179/N180) (2xLF-60x3([])) | 0.26762
Peça (N181/N182) (2xLF-60x3([])) | 0.26762
Peça (N183/N184) (2xLF-60x3([])) | 0.26762

# IfcMember: R 12 (24)
In: Planta
Description: Barra maciça. Aço laminado; Material: A-36 250Mpa
Pset_MemberCommon - LoadBearing: yes
Name
Peça (N91/N119) (R 12)
Peça (N91/N53) (R 12)
Peça (N54/N25) (R 12)
Peça (N21/N58) (R 12)
Peça (N58/N86) (R 12)
Peça (N124/N86) (R 12)
Peça (N87/N124) (R 12)
Peça (N120/N91) (R 12)
Peça (N87/N58) (R 12)
Peça (N54/N91) (R 12)
Peça (N38/N3) (R 12)
Peça (N4/N42) (R 12)
Peça (N71/N42) (R 12)
Peça (N38/N75) (R 12)
Peça (N75/N37) (R 12)
Peça (N42/N70) (R 12)
Peça (N71/N108) (R 12)
Peça (N104/N75) (R 12)
Peça (N108/N70) (R 12)
Peça (N75/N103) (R 12)
Peça (N58/N20) (R 12)
Peça (N25/N53) (R 12)
Peça (N3/N37) (R 12)
Peça (N42/N2) (R 12)
