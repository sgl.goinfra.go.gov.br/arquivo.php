Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView]
File name: EST
Time: 2025-08-14T10:53:12
Written by: BIMServer.center IFC Preprocessor 1.0

# IfcBuildingStorey (2)
Elevation: 0 m

# IfcBeam: 2xC200X75X20X3([]) (5)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N4/N1) (2xC200X75X20X3([]))
Peça (N10/N7) (2xC200X75X20X3([]))
Peça (N28/N25) (2xC200X75X20X3([]))
Peça (N16/N13) (2xC200X75X20X3([]))
Peça (N22/N19) (2xC200X75X20X3([]))

# IfcBeam: C150X60X17X3 (4)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N27/N3) (C150X60X17X3)
Peça (N31/N35) (C150X60X17X3)
Peça (N36/N40) (C150X60X17X3)
Peça (N41/N45) (C150X60X17X3)

# IfcBeam: LF-60x3 (12)
In: Planta
Description: Cantoneira simétrica dobrada. Aço dobrado; PredefinedType: BEAM; Material: A-36
Pset_BeamCommon - LoadBearing: yes
Name
Peça (N47/N46) (LF-60x3)
Peça (N48/N47) (LF-60x3)
Peça (N49/N48) (LF-60x3)
Peça (N51/N50) (LF-60x3)
Peça (N52/N51) (LF-60x3)
Peça (N53/N52) (LF-60x3)
Peça (N55/N54) (LF-60x3)
Peça (N57/N56) (LF-60x3)
Peça (N58/N57) (LF-60x3)
Peça (N59/N58) (LF-60x3)
Peça (N60/N55) (LF-60x3)
Peça (N61/N60) (LF-60x3)

# IfcColumn: 2xC150X60X17X3([]) (10)
In: Planta
Description: U dobrado enrijecido. Aço dobrado; Material: A-36
Pset_ColumnCommon - LoadBearing: yes
Name | Length (m)
Peça (N5/N2) (2xC150X60X17X3([])) | 0.610026
Peça (N6/N3) (2xC150X60X17X3([])) | 0.147484
Peça (N11/N8) (2xC150X60X17X3([])) | 0.610026
Peça (N12/N9) (2xC150X60X17X3([])) | 0.147484
Peça (N17/N14) (2xC150X60X17X3([])) | 0.610026
Peça (N18/N15) (2xC150X60X17X3([])) | 0.147484
Peça (N23/N20) (2xC150X60X17X3([])) | 0.610026
Peça (N24/N21) (2xC150X60X17X3([])) | 0.147484
Peça (N29/N26) (2xC150X60X17X3([])) | 0.610026
Peça (N30/N27) (2xC150X60X17X3([])) | 0.147484

# IfcMember: R 12 (20)
In: Planta
Description: Barra maciça. Aço laminado; Material: A-36 250Mpa
Pset_MemberCommon - LoadBearing: yes
Name
Peça (N37/N41) (R 12)
Peça (N37/N43) (R 12)
Peça (N39/N43) (R 12)
Peça (N39/N45) (R 12)
Peça (N40/N44) (R 12)
Peça (N38/N44) (R 12)
Peça (N38/N42) (R 12)
Peça (N36/N42) (R 12)
Peça (N34/N40) (R 12)
Peça (N3/N34) (R 12)
Peça (N35/N39) (R 12)
Peça (N9/N35) (R 12)
Peça (N32/N36) (R 12)
Peça (N27/N32) (R 12)
Peça (N31/N37) (R 12)
Peça (N21/N31) (R 12)
Peça (N9/N33) (R 12)
Peça (N15/N34) (R 12)
Peça (N21/N33) (R 12)
Peça (N15/N32) (R 12)
