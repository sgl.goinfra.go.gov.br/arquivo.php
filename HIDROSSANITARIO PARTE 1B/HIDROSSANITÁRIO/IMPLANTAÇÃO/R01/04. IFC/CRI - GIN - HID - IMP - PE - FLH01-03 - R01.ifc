Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 93b3341a-37f4-4b9e-948e-b4238885f01a, VersionGUID: d288aa71-7411-45dd-b94b-a96521e2f2fb, NumberOfSaves: 97], CoordinateReference [CoordinateBase: Coordenadas compartilhadas]
File name: Ginasio Cristianopolis R01.ifc
Time: 2025-05-13T17:28:49-03:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.0.32 (PTB) - IFC 25.4.0.32

# IfcProject, 3
LongName: INSTALAÇÕES SANITÁRIO E PLUVIAL; Phase: /2

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 m

# IfcBuilding, GINÁSIO DE ESPORTES PADRÃO ADEQUAÇÃO DE ACESSIBILIDADE - CRISTIANÓPOLIS
LongName: GINÁSIO DE ESPORTES PADRÃO ADEQUAÇÃO DE ACESSIBILIDADE - CRISTIANÓPOLIS
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Nível:Level 1 (3)
In: GINÁSIO DE ESPORTES PADRÃO ADEQUAÇÃO DE ACESSIBILIDADE - CRISTIANÓPOLIS
Name | LongName | Elevation (m)
Térreo-COM | Térreo-COM | 0.3
Cobertura-COM | Cobertura-COM | 3.2
Base Res. | Base Res. | 4.32

# IfcBuildingElementProxy: Anel de Concreto Perfurado para Sumidouro_Rodrigo MEP:Anel de Concreto Perfurado para Sumidouro (8)
In: Térreo-COM
Type - Material: .CONCRETO
Pset_BuildingElementProxyCommon - Reference: Anel de Concreto Perfurado para Sumidouro; sets with these values: 2
Name (Anel de Concreto Perfurado para Sumidouro_Rodrigo MEP:Anel de Concreto Perfurado para Sumidouro:...)
3071339
3071340
3071342
3071343
3138204
3138205
3138207
3138208

# IfcBuildingElementProxy: Brita_Rodrigo MEP:Brita (2)
In: Térreo-COM
Type - Material: Brita
Pset_BuildingElementProxyCommon - Reference: Brita; sets with these values: 2
Name (Brita_Rodrigo MEP:Brita:...)
3071345
3138210

# IfcBuildingElementProxy: Tampa Fossa_Rodrigo MEP:Tampa Fossa (2)
In: Térreo-COM
Type - Material: .CONCRETO
Pset_BuildingElementProxyCommon - Reference: Tampa Fossa; sets with these values: 2
Name (Tampa Fossa_Rodrigo MEP:Tampa Fossa:...)
3071344
3138209

# IfcBuildingElementProxy: Tampa para Fossa, Filtro Anaerobio e Sumidouro_Rodrigo MEP:tampa para Fossa, Filtro Anaerobio e Sumidouro (2)
In: Térreo-COM
Type - Material: .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_BuildingElementProxyCommon - Reference: tampa para Fossa, Filtro Anaerobio e Sumidouro; sets with these values: 2
Name (Tampa para Fossa, Filtro Anaerobio e Sumidouro_Rodrigo MEP:tampa para Fossa, Filtro Anaerobio e Sumidouro:...)
3071341
3138206

# IfcDistributionPort (510)
Description: Flow
Name | FlowDirection | Group
OutPort_3056640_3 | SOURCE
OutPort_3056645_3 | SOURCE
OutPort_3056650_3 | SOURCE
OutPort_3056655_3 | SOURCE
OutPort_3056660_3 | SOURCE
OutPort_3056665_3 | SOURCE
OutPort_3056670_3 | SOURCE
OutPort_3056675_3 | SOURCE | Esgoto Primário 5
Port_3068398_0 | SOURCEANDSINK | Esgoto Primário 1
Port_3068398_1 | SOURCEANDSINK | Esgoto Primário 1
Port_3068659_0 | SOURCEANDSINK | Esgoto Primário 2
Port_3068659_1 | SOURCEANDSINK | Esgoto Primário 2
Port_3068675_0 | SOURCEANDSINK | Esgoto Primário 3
Port_3068675_1 | SOURCEANDSINK | Esgoto Primário 3
Port_3068701_2 | SOURCEANDSINK | Esgoto Primário 3
Port_3068684_0 | SOURCEANDSINK | Esgoto Primário 3
Port_3068701_1 | SOURCEANDSINK | Esgoto Primário 3
Port_3068684_1 | SOURCEANDSINK | Esgoto Primário 3
Port_3068850_0 | SOURCEANDSINK | Esgoto Primário 4
Port_3068850_1 | SOURCEANDSINK | Esgoto Primário 4
Port_3069098_0 | SOURCEANDSINK | Esgoto Primário 6
Port_3069098_1 | SOURCEANDSINK | Esgoto Primário 6
Port_3069944_0 | SOURCEANDSINK | Esgoto Primário 7
Port_3069944_1 | SOURCEANDSINK | Esgoto Primário 7
Port_3069958_0 | SOURCEANDSINK | Esgoto Primário 8
Port_3069958_1 | SOURCEANDSINK | Esgoto Primário 8
Port_3070050_0 | SOURCEANDSINK | Esgoto Primário 9
Port_3070050_1 | SOURCEANDSINK | Esgoto Primário 9
Port_3070066_0 | SOURCEANDSINK | Esgoto Primário 10
Port_3070066_1 | SOURCEANDSINK | Esgoto Primário 10
Port_3071110_0 | SOURCEANDSINK | Esgoto Primário 11
Port_3071110_1 | SOURCEANDSINK | Esgoto Primário 11
OutPort_3071190_3 | SOURCE
Port_3071277_0 | SOURCEANDSINK | Esgoto Primário 12
Port_3071277_1 | SOURCEANDSINK | Esgoto Primário 12
Port_3073941_0 | SOURCEANDSINK | Esgoto Primário 13
Port_3073941_1 | SOURCEANDSINK | Esgoto Primário 13
Port_3074030_0 | SOURCEANDSINK | Esgoto Primário 14
Port_3074063_1 | SOURCEANDSINK | Esgoto Primário 14
Port_3074030_1 | SOURCEANDSINK | Esgoto Primário 14
Port_3074047_0 | SOURCEANDSINK | Esgoto Primário 14
Port_3074063_2 | SOURCEANDSINK | Esgoto Primário 14
Port_3074047_1 | SOURCEANDSINK | Esgoto Primário 14
Port_3074156_0 | SOURCEANDSINK | Esgoto Primário 15
Port_3074156_1 | SOURCEANDSINK | Esgoto Primário 15
Port_3074196_0 | SOURCEANDSINK | Esgoto Primário 16
Port_3074211_1 | SOURCEANDSINK | Esgoto Primário 16
Port_3074196_1 | SOURCEANDSINK | Esgoto Primário 16
Port_3074205_0 | SOURCEANDSINK | Esgoto Primário 16
Port_3074211_2 | SOURCEANDSINK | Esgoto Primário 16
Port_3074205_1 | SOURCEANDSINK | Esgoto Primário 16
Port_3074331_0 | SOURCEANDSINK | Esgoto Primário 17
Port_3074331_1 | SOURCEANDSINK | Esgoto Primário 17
Port_3074432_0 | SOURCEANDSINK | Esgoto Primário 19
Port_3074447_2 | SOURCEANDSINK | Esgoto Primário 19
Port_3074432_1 | SOURCEANDSINK | Esgoto Primário 19
Port_3074441_0 | SOURCEANDSINK | Esgoto Primário 19
Port_3074447_1 | SOURCEANDSINK | Esgoto Primário 19
Port_3074441_1 | SOURCEANDSINK | Esgoto Primário 19
Port_3074550_0 | SOURCEANDSINK | Esgoto Primário 20
Port_3074550_1 | SOURCEANDSINK | Esgoto Primário 20
Port_3074681_0 | SOURCEANDSINK | Esgoto Primário 21
Port_3074681_1 | SOURCEANDSINK | Esgoto Primário 21
Port_3074736_0 | SOURCEANDSINK | Esgoto Primário 22
Port_3074736_1 | SOURCEANDSINK | Esgoto Primário 22
Port_3074851_0 | SOURCEANDSINK | Esgoto Primário 23
Port_3074851_1 | SOURCEANDSINK | Esgoto Primário 23
Port_3080617_0 | SOURCEANDSINK | AF 4
Port_3082215_2 | SOURCEANDSINK | AF 4
Port_3080617_1 | SOURCEANDSINK | AF 4
Port_3081562_3 | SOURCEANDSINK | AF 4
Port_3080619_0 | SOURCEANDSINK | AF 4
Port_3080619_1 | SOURCEANDSINK | AF 4
Port_3081572_1 | SOURCEANDSINK | AF 4
Port_3080623_0 | SOURCEANDSINK | AF 14
Port_3080623_1 | SOURCEANDSINK | AF 14
Port_3080649_0 | SOURCEANDSINK | AF 9
Port_3085521_2 | SOURCEANDSINK | AF 9
Port_3080649_1 | SOURCEANDSINK | AF 9
Port_3080651_0 | SOURCEANDSINK | AF 5
Port_3080651_1 | SOURCEANDSINK | AF 5
Port_3080653_1 | SOURCEANDSINK | AF 6
Port_3080653_2 | SOURCEANDSINK | AF 6
Port_3080655_1 | SOURCEANDSINK | AF 9
Port_3080655_2 | SOURCEANDSINK | AF 9
Port_3080655_3 | SOURCEANDSINK | AF 9
Port_3085465_0 | SOURCEANDSINK | AF 9
Port_3080656_0 | SOURCEANDSINK | AF 15
Port_3080656_1 | SOURCEANDSINK | AF 15
Port_3080661_0 | SOURCEANDSINK | AF 4
Port_3082250_1 | SOURCEANDSINK | AF 4
Port_3080661_1 | SOURCEANDSINK | AF 4
Port_3080715_3 | SOURCEANDSINK | AF 4
Port_3080677_1 | SOURCEANDSINK | AF 4
Port_3165862_1 | SOURCEANDSINK | AF 4
Port_3080677_2 | SOURCEANDSINK | AF 4
Port_3165854_1 | SOURCEANDSINK | AF 4
Port_3080677_3 | SOURCEANDSINK | AF 4
Port_3083501_0 | SOURCEANDSINK | AF 4
Port_3080678_0 | SOURCEANDSINK | AF 4
Port_3165854_2 | SOURCEANDSINK | AF 4
Port_3080678_1 | SOURCEANDSINK | AF 4
Port_3165856_2 | SOURCEANDSINK | AF 4
Port_3080681_0 | SOURCEANDSINK | AF 4
Port_3083804_2 | SOURCEANDSINK | AF 4
Port_3080681_1 | SOURCEANDSINK | AF 4
Port_3083859_1 | SOURCEANDSINK | AF 4
Port_3080683_0 | SOURCEANDSINK | AF 3
Port_3080683_1 | SOURCEANDSINK | AF 3
Port_3080687_0 | SOURCEANDSINK | AF 4
Port_3155748_1 | SOURCEANDSINK | AF 4
Port_3080687_1 | SOURCEANDSINK | AF 4
Port_3084645_2 | SOURCEANDSINK | AF 4
Port_3080689_0 | SOURCEANDSINK | AF 4
Port_3080689_1 | SOURCEANDSINK | AF 4
Port_3084645_1 | SOURCEANDSINK | AF 4
Port_3080692_0 | SOURCEANDSINK | AF 4
Port_3165882_2 | SOURCEANDSINK | AF 4
Port_3080692_1 | SOURCEANDSINK | AF 4
Port_3084725_1 | SOURCEANDSINK | AF 4
Port_3080709_0 | SOURCEANDSINK | AF 4
Port_3082870_1 | SOURCEANDSINK | AF 4
Port_3080709_1 | SOURCEANDSINK | AF 4
Port_3080715_1 | SOURCEANDSINK | AF 4
Port_3165856_1 | SOURCEANDSINK | AF 4
Port_3080715_2 | SOURCEANDSINK | AF 4
Port_3080716_1 | SOURCEANDSINK | AF 4
Port_3080716_0 | SOURCEANDSINK | AF 4
Port_3081562_1 | SOURCEANDSINK | AF 4
Port_3080759_0 | SOURCEANDSINK | AF 7
Port_3090925_1 | SOURCEANDSINK | AF 7
Port_3080759_1 | SOURCEANDSINK | AF 7
Port_3091113_1 | SOURCEANDSINK | AF 7
Port_3080761_0 | SOURCEANDSINK | AF 7
Port_3080761_1 | SOURCEANDSINK | AF 7
Port_3091126_1 | SOURCEANDSINK | AF 7
Port_3080767_0 | SOURCEANDSINK | AF 7
Port_3080767_1 | SOURCEANDSINK | AF 7
Port_3090421_1 | SOURCEANDSINK | AF 7
Port_3080773_0 | SOURCEANDSINK | AF 7
Port_3080773_1 | SOURCEANDSINK | AF 7
Port_3090631_1 | SOURCEANDSINK | AF 7
Port_3080777_0 | SOURCEANDSINK | AF 7
Port_3089273_3 | SOURCEANDSINK | AF 7
Port_3080777_1 | SOURCEANDSINK | AF 7
Port_3089593_1 | SOURCEANDSINK | AF 7
Port_3080779_0 | SOURCEANDSINK | AF 7
Port_3089826_3 | SOURCEANDSINK | AF 7
Port_3080779_1 | SOURCEANDSINK | AF 7
Port_3089936_2 | SOURCEANDSINK | AF 7
Port_3080781_0 | SOURCEANDSINK | AF 7
Port_3080781_1 | SOURCEANDSINK | AF 7
Port_3089936_1 | SOURCEANDSINK | AF 7
Port_3080789_0 | SOURCEANDSINK | AF 7
Port_3089871_1 | SOURCEANDSINK | AF 7
Port_3080789_1 | SOURCEANDSINK | AF 7
Port_3089873_2 | SOURCEANDSINK | AF 7
Port_3080791_0 | SOURCEANDSINK | AF 7
Port_3080791_1 | SOURCEANDSINK | AF 7
Port_3089873_1 | SOURCEANDSINK | AF 7
Port_3080805_0 | SOURCEANDSINK | AF 8
Port_3080805_1 | SOURCEANDSINK | AF 8
Port_3087815_1 | SOURCEANDSINK | AF 8
Port_3080813_0 | SOURCEANDSINK | AF 8
Port_3088024_2 | SOURCEANDSINK | AF 8
Port_3080813_1 | SOURCEANDSINK | AF 8
Port_3142997_2 | SOURCEANDSINK | AF 8
Port_3080817_0 | SOURCEANDSINK | AF 8
Port_3080817_1 | SOURCEANDSINK | AF 8
Port_3088024_1 | SOURCEANDSINK | AF 8
Port_3081384_0 | SOURCEANDSINK | AF 18
Port_3081384_1 | SOURCEANDSINK | AF 18
Port_3081397_0 | SOURCEANDSINK | AF 20
Port_3081397_1 | SOURCEANDSINK | AF 20
Port_3081405_0 | SOURCEANDSINK | AF 24
Port_3081405_1 | SOURCEANDSINK | AF 24
Port_3081415_0 | SOURCEANDSINK | AF 25
Port_3081415_1 | SOURCEANDSINK | AF 25
Port_3081423_0 | SOURCEANDSINK | AF 7
Port_3165831_2 | SOURCEANDSINK | AF 7
Port_3081423_1 | SOURCEANDSINK | AF 7
Port_3090177_2 | SOURCEANDSINK | AF 7
Port_3081562_2 | SOURCEANDSINK | AF 4
Port_3081563_1 | SOURCEANDSINK | AF 4
Port_3081563_0 | SOURCEANDSINK | AF 4
Port_3081572_2 | SOURCEANDSINK | AF 4
Port_3082215_1 | SOURCEANDSINK | AF 4
Port_3081716_0 | SOURCEANDSINK | AF 4
Port_3082870_2 | SOURCEANDSINK | AF 4
Port_3081716_1 | SOURCEANDSINK | AF 4
Port_3082874_2 | SOURCEANDSINK | AF 4
Port_3081894_0 | SOURCEANDSINK | AF 4
Port_3082537_1 | SOURCEANDSINK | AF 4
Port_3081894_1 | SOURCEANDSINK | AF 4
Port_3082874_1 | SOURCEANDSINK | AF 4
Port_3082250_2 | SOURCEANDSINK | AF 4
Port_3082251_1 | SOURCEANDSINK | AF 4
Port_3082250_3 | SOURCEANDSINK | AF 4
Port_3082325_0 | SOURCEANDSINK | AF 4
Port_3082251_0 | SOURCEANDSINK | AF 4
Port_3082507_1 | SOURCEANDSINK | AF 4
Port_3082280_0 | SOURCEANDSINK | AF 4
Port_3082342_1 | SOURCEANDSINK | AF 4
Port_3082280_1 | SOURCEANDSINK | AF 4
Port_3082325_1 | SOURCEANDSINK | AF 4
Port_3082346_1 | SOURCEANDSINK | AF 4
Port_3082333_0 | SOURCEANDSINK | AF 4
Port_3082342_2 | SOURCEANDSINK | AF 4
Port_3082333_1 | SOURCEANDSINK | AF 4
Port_3082346_2 | SOURCEANDSINK | AF 4
Port_3082361_0 | SOURCEANDSINK | AF 4
Port_3082537_3 | SOURCEANDSINK | AF 4
Port_3082361_1 | SOURCEANDSINK | AF 4
Port_3082998_2 | SOURCEANDSINK | AF 4
Port_3082507_2 | SOURCEANDSINK | AF 4
Port_3082538_0 | SOURCEANDSINK | AF 4
Port_3082537_2 | SOURCEANDSINK | AF 4
Port_3082538_1 | SOURCEANDSINK | AF 4
Port_3082910_0 | SOURCEANDSINK | AF 4
Port_3082998_1 | SOURCEANDSINK | AF 4
Port_3082910_1 | SOURCEANDSINK | AF 4
Port_3083372_0 | SOURCEANDSINK | AF 4
Port_3083372_1 | SOURCEANDSINK | AF 4
Port_3083760_1 | SOURCEANDSINK | AF 4
Port_3083383_0 | SOURCEANDSINK | AF 4
Port_3083383_1 | SOURCEANDSINK | AF 4
Port_3083529_1 | SOURCEANDSINK | AF 4
Port_3083500_1 | SOURCEANDSINK | AF 4
Port_3083753_0 | SOURCEANDSINK | AF 4
Port_3083500_2 | SOURCEANDSINK | AF 4
Port_3083501_1 | SOURCEANDSINK | AF 4
Port_3083500_3 | SOURCEANDSINK | AF 4
Port_3083511_0 | SOURCEANDSINK | AF 4
Port_3083511_1 | SOURCEANDSINK | AF 4
Port_3083533_2 | SOURCEANDSINK | AF 4
Port_3083519_0 | SOURCEANDSINK | AF 4
Port_3083529_2 | SOURCEANDSINK | AF 4
Port_3083519_1 | SOURCEANDSINK | AF 4
Port_3083533_1 | SOURCEANDSINK | AF 4
Port_3083549_0 | SOURCEANDSINK | AF 4
Port_3083760_2 | SOURCEANDSINK | AF 4
Port_3083549_1 | SOURCEANDSINK | AF 4
Port_3083752_3 | SOURCEANDSINK | AF 4
Port_3083752_1 | SOURCEANDSINK | AF 4
Port_3083859_2 | SOURCEANDSINK | AF 4
Port_3083752_2 | SOURCEANDSINK | AF 4
Port_3083753_1 | SOURCEANDSINK | AF 4
Port_3083804_1 | SOURCEANDSINK | AF 4
Port_3083936_1 | SOURCEANDSINK | AF 4
Port_3165882_1 | SOURCEANDSINK | AF 4
Port_3083936_2 | SOURCEANDSINK | AF 4
Port_3083937_1 | SOURCEANDSINK | AF 4
Port_3083936_3 | SOURCEANDSINK | AF 4
Port_3084183_0 | SOURCEANDSINK | AF 4
Port_3083937_0 | SOURCEANDSINK | AF 4
Port_3165862_2 | SOURCEANDSINK | AF 4
Port_3084004_0 | SOURCEANDSINK | AF 4
Port_3084004_1 | SOURCEANDSINK | AF 4
Port_3084207_1 | SOURCEANDSINK | AF 4
Port_3084183_1 | SOURCEANDSINK | AF 4
Port_3084211_2 | SOURCEANDSINK | AF 4
Port_3084196_0 | SOURCEANDSINK | AF 4
Port_3165895_2 | SOURCEANDSINK | AF 4
Port_3084196_1 | SOURCEANDSINK | AF 4
Port_3084211_1 | SOURCEANDSINK | AF 4
Port_3084207_2 | SOURCEANDSINK | AF 4
Port_3165895_1 | SOURCEANDSINK | AF 4
Port_3084316_0 | SOURCEANDSINK | AF 4
Port_3084725_2 | SOURCEANDSINK | AF 4
Port_3084316_1 | SOURCEANDSINK | AF 4
Port_3084643_1 | SOURCEANDSINK | AF 4
Port_3084643_2 | SOURCEANDSINK | AF 4
Port_3155749_0 | SOURCEANDSINK | AF 4
Port_3085465_1 | SOURCEANDSINK | AF 9
Port_3085521_1 | SOURCEANDSINK | AF 9
Port_3085672_1 | SOURCEANDSINK | AF 27
Port_3085672_2 | SOURCEANDSINK | AF 27
Port_3085676_1 | SOURCEANDSINK | AF 26
Port_3085676_2 | SOURCEANDSINK | AF 26
Port_3085678_1 | SOURCEANDSINK | AF 21
Port_3085678_2 | SOURCEANDSINK | AF 21
Port_3085680_1 | SOURCEANDSINK | AF 22
Port_3085680_2 | SOURCEANDSINK | AF 22
Port_3085682_1 | SOURCEANDSINK | AF 19
Port_3085682_2 | SOURCEANDSINK | AF 19
Port_3085684_1 | SOURCEANDSINK | AF 16
Port_3085684_2 | SOURCEANDSINK | AF 16
Port_3085744_1 | SOURCEANDSINK | AF 11
Port_3085744_2 | SOURCEANDSINK | AF 11
Port_3085744_3 | SOURCEANDSINK | AF 11
Port_3086186_0 | SOURCEANDSINK | AF 11
Port_3085745_0 | SOURCEANDSINK | AF 17
Port_3085745_1 | SOURCEANDSINK | AF 17
Port_3086186_1 | SOURCEANDSINK | AF 11
Port_3169159_2 | SOURCEANDSINK | AF 11
Port_3086196_0 | SOURCEANDSINK | AF 11
Port_3169159_1 | SOURCEANDSINK | AF 11
Port_3086196_1 | SOURCEANDSINK | AF 11
Port_3086213_1 | SOURCEANDSINK | AF 11
Port_3086207_0 | SOURCEANDSINK | AF 10
Port_3086207_1 | SOURCEANDSINK | AF 10
Port_3169543_1 | SOURCEANDSINK | AF 10
Port_3086213_2 | SOURCEANDSINK | AF 11
Port_3086217_0 | SOURCEANDSINK | AF 29
Port_3086217_1 | SOURCEANDSINK | AF 29
Port_3086524_1 | SOURCEANDSINK | AF 30
Port_3086524_2 | SOURCEANDSINK | AF 30
Port_3086728_0 | SOURCEANDSINK | AF 10
Port_3169543_2 | SOURCEANDSINK | AF 10
Port_3086728_1 | SOURCEANDSINK | AF 10
Port_3087594_0 | SOURCEANDSINK | AF 8
Port_3089047_1 | SOURCEANDSINK | AF 8
Port_3087594_1 | SOURCEANDSINK | AF 8
Port_3087860_1 | SOURCEANDSINK | AF 8
Port_3087669_1 | SOURCEANDSINK | AF 8
Port_3087669_2 | SOURCEANDSINK | AF 8
Port_3087669_3 | SOURCEANDSINK | AF 8
Port_3089048_0 | SOURCEANDSINK | AF 8
Port_3087670_0 | SOURCEANDSINK | AF 28
Port_3087670_1 | SOURCEANDSINK | AF 28
Port_3087803_0 | SOURCEANDSINK | AF 8
Port_3087815_2 | SOURCEANDSINK | AF 8
Port_3087803_1 | SOURCEANDSINK | AF 8
Port_3087860_3 | SOURCEANDSINK | AF 8
Port_3087840_0 | SOURCEANDSINK | AF 8
Port_3089047_3 | SOURCEANDSINK | AF 8
Port_3087840_1 | SOURCEANDSINK | AF 8
Port_3089089_1 | SOURCEANDSINK | AF 8
Port_3087860_2 | SOURCEANDSINK | AF 8
Port_3087876_0 | SOURCEANDSINK | AF 8
Port_3087876_1 | SOURCEANDSINK | AF 8
Port_3142997_1 | SOURCEANDSINK | AF 8
Port_3088993_0 | SOURCEANDSINK | AF 8
Port_3089089_2 | SOURCEANDSINK | AF 8
Port_3088993_1 | SOURCEANDSINK | AF 8
Port_3089047_2 | SOURCEANDSINK | AF 8
Port_3089048_1 | SOURCEANDSINK | AF 8
Port_3089273_1 | SOURCEANDSINK | AF 7
Port_3165831_1 | SOURCEANDSINK | AF 7
Port_3089273_2 | SOURCEANDSINK | AF 7
Port_3089274_1 | SOURCEANDSINK | AF 7
Port_3089274_0 | SOURCEANDSINK | AF 7
Port_3089330_0 | SOURCEANDSINK | AF 7
Port_3089826_1 | SOURCEANDSINK | AF 7
Port_3089330_1 | SOURCEANDSINK | AF 7
Port_3089871_2 | SOURCEANDSINK | AF 7
Port_3089593_2 | SOURCEANDSINK | AF 7
Port_3089827_0 | SOURCEANDSINK | AF 7
Port_3089826_2 | SOURCEANDSINK | AF 7
Port_3089827_1 | SOURCEANDSINK | AF 7
Port_3090177_1 | SOURCEANDSINK | AF 7
Port_3157357_0 | SOURCEANDSINK | AF 7
Port_3090327_0 | SOURCEANDSINK | AF 7
Port_3165129_2 | SOURCEANDSINK | AF 7
Port_3090327_1 | SOURCEANDSINK | AF 7
Port_3090413_3 | SOURCEANDSINK | AF 7
Port_3090413_1 | SOURCEANDSINK | AF 7
Port_3090587_0 | SOURCEANDSINK | AF 7
Port_3090413_2 | SOURCEANDSINK | AF 7
Port_3090414_1 | SOURCEANDSINK | AF 7
Port_3090414_0 | SOURCEANDSINK | AF 7
Port_3157356_1 | SOURCEANDSINK | AF 7
Port_3090421_2 | SOURCEANDSINK | AF 7
Port_3165129_1 | SOURCEANDSINK | AF 7
Port_3090586_1 | SOURCEANDSINK | AF 7
Port_3168814_1 | SOURCEANDSINK | AF 7
Port_3090586_2 | SOURCEANDSINK | AF 7
Port_3090587_1 | SOURCEANDSINK | AF 7
Port_3090586_3 | SOURCEANDSINK | AF 7
Port_3090615_0 | SOURCEANDSINK | AF 7
Port_3090615_1 | SOURCEANDSINK | AF 7
Port_3090635_1 | SOURCEANDSINK | AF 7
Port_3090623_0 | SOURCEANDSINK | AF 7
Port_3090631_2 | SOURCEANDSINK | AF 7
Port_3090623_1 | SOURCEANDSINK | AF 7
Port_3090635_2 | SOURCEANDSINK | AF 7
Port_3090696_0 | SOURCEANDSINK | AF 7
Port_3090925_3 | SOURCEANDSINK | AF 7
Port_3090696_1 | SOURCEANDSINK | AF 7
Port_3091087_2 | SOURCEANDSINK | AF 7
Port_3090925_2 | SOURCEANDSINK | AF 7
Port_3090926_0 | SOURCEANDSINK | AF 7
Port_3090926_1 | SOURCEANDSINK | AF 7
Port_3168830_1 | SOURCEANDSINK | AF 7
Port_3091028_0 | SOURCEANDSINK | AF 7
Port_3091028_1 | SOURCEANDSINK | AF 7
Port_3091089_1 | SOURCEANDSINK | AF 7
Port_3091087_1 | SOURCEANDSINK | AF 7
Port_3091089_2 | SOURCEANDSINK | AF 7
Port_3091102_0 | SOURCEANDSINK | AF 7
Port_3091113_2 | SOURCEANDSINK | AF 7
Port_3091102_1 | SOURCEANDSINK | AF 7
Port_3091130_2 | SOURCEANDSINK | AF 7
Port_3091115_0 | SOURCEANDSINK | AF 7
Port_3091126_2 | SOURCEANDSINK | AF 7
Port_3091115_1 | SOURCEANDSINK | AF 7
Port_3091130_1 | SOURCEANDSINK | AF 7
OutPort_3091416_3 | SOURCE
Port_3091509_0 | SOURCEANDSINK | Esgoto Primário 24
Port_3091509_1 | SOURCEANDSINK | Esgoto Primário 24
OutPort_3092257_3 | SOURCE
Port_3111870_0 | SOURCEANDSINK | Esgoto Primário 26
Port_3111870_1 | SOURCEANDSINK | Esgoto Primário 26
Port_3111946_0 | SOURCEANDSINK | Esgoto Primário 25
Port_3111946_1 | SOURCEANDSINK | Esgoto Primário 25
OutPort_3131679_3 | SOURCE
Port_3132036_0 | SOURCEANDSINK | Esgoto Primário 27
Port_3132036_1 | SOURCEANDSINK | Esgoto Primário 27
Port_3132115_0 | SOURCEANDSINK | Esgoto Primário 18
Port_3132115_1 | SOURCEANDSINK | Esgoto Primário 18
OutPort_3132259_3 | SOURCE
Port_3132394_0 | SOURCEANDSINK | Esgoto Primário 28
Port_3132394_1 | SOURCEANDSINK | Esgoto Primário 28
OutPort_3137901_3 | SOURCE
Port_3138146_0 | SOURCEANDSINK | Esgoto Primário 29
Port_3138146_1 | SOURCEANDSINK | Esgoto Primário 29
Port_3141387_0 | SOURCEANDSINK | Esgoto Primário 30
Port_3141387_1 | SOURCEANDSINK | Esgoto Primário 30
InPort_3155630_1 | SINK | AF 1
InPort_3155640_1 | SINK | AF 2
OutPort_3156325_0 | SOURCE | AF 2
InPort_3155661_1 | SINK | AF 2
OutPort_3156847_0 | SOURCE | AF 2
InPort_3155666_1 | SINK | AF 2
OutPort_3158019_0 | SOURCE | AF 2
Port_3155734_0 | SOURCEANDSINK | AF 4
Port_3155748_3 | SOURCEANDSINK | AF 4
Port_3155734_1 | SOURCEANDSINK | AF 4
Port_3155909_1 | SOURCEANDSINK | AF 4
Port_3155748_2 | SOURCEANDSINK | AF 4
Port_3155749_1 | SOURCEANDSINK | AF 4
Port_3155899_0 | SOURCEANDSINK | AF 4
Port_3155909_2 | SOURCEANDSINK | AF 4
Port_3155899_1 | SOURCEANDSINK | AF 4
Port_3155919_2 | SOURCEANDSINK | AF 4
Port_3155911_0 | SOURCEANDSINK | AF 4
Port_3155919_1 | SOURCEANDSINK | AF 4
Port_3155911_1 | SOURCEANDSINK | AF 4
Port_3155983_2 | SOURCEANDSINK | AF 4
Port_3155921_0 | SOURCEANDSINK | AF 4
Port_3155983_1 | SOURCEANDSINK | AF 4
Port_3155921_1 | SOURCEANDSINK | AF 4
Port_3156213_1 | SOURCEANDSINK | AF 4
Port_3156213_2 | SOURCEANDSINK | AF 4
Port_3156236_0 | SOURCEANDSINK | AF 4
Port_3156236_1 | SOURCEANDSINK | AF 4
Port_3156249_2 | SOURCEANDSINK | AF 4
Port_3156249_1 | SOURCEANDSINK | AF 4
Port_3156313_1 | SOURCEANDSINK | AF 2
Port_3156313_2 | SOURCEANDSINK | AF 2
InPort_3159608_0 | SINK | AF 2
OutPort_3156313_3 | SOURCE | AF 2
Port_3156314_0 | SOURCEANDSINK | AF 13
Port_3156314_1 | SOURCEANDSINK | AF 13
InPort_3156325_1 | SINK | AF 2
OutPort_3156329_1 | SOURCE | AF 2
InPort_3156329_2 | SINK | AF 2
OutPort_3156326_0 | SOURCE | AF 2
InPort_3156326_1 | SINK | AF 2
OutPort_3156333_1 | SOURCE | AF 2
InPort_3156333_2 | SINK | AF 2
OutPort_3159668_0 | SOURCE | AF 2
InPort_3156855_2 | SINK | AF 2
OutPort_3156827_0 | SOURCE | AF 2
InPort_3156827_1 | SINK | AF 2
OutPort_3158935_2 | SOURCE | AF 2
Port_3156835_1 | SOURCEANDSINK | AF 2
Port_3156835_2 | SOURCEANDSINK | AF 2
InPort_3158906_1 | SINK | AF 2
OutPort_3156835_3 | SOURCE | AF 2
Port_3156836_0 | SOURCEANDSINK | AF 23
Port_3156836_1 | SOURCEANDSINK | AF 23
InPort_3156847_1 | SINK | AF 2
OutPort_3156851_1 | SOURCE | AF 2
InPort_3156851_2 | SINK | AF 2
OutPort_3156848_0 | SOURCE | AF 2
InPort_3156848_1 | SINK | AF 2
OutPort_3156855_1 | SOURCE | AF 2
InPort_3157376_2 | SINK | AF 2
OutPort_3157348_0 | SOURCE | AF 2
InPort_3157348_1 | SINK | AF 2
OutPort_3159836_1 | SOURCE | AF 2
Port_3157356_2 | SOURCEANDSINK | AF 7
Port_3157357_1 | SOURCEANDSINK | AF 7
Port_3157356_3 | SOURCEANDSINK | AF 7
InPort_3157364_0 | SINK | AF 2
OutPort_3157376_1 | SOURCE | AF 2
InPort_3159543_1 | SINK | AF 2
OutPort_3157364_1 | SOURCE | AF 2
InPort_3159538_2 | SINK | AF 2
OutPort_3158003_0 | SOURCE | AF 2
InPort_3158003_1 | SINK | AF 2
OutPort_3159543_2 | SOURCE | AF 2
InPort_3158019_1 | SINK | AF 2
OutPort_3159524_1 | SOURCE | AF 2
InPort_3159524_2 | SINK | AF 2
OutPort_3158020_0 | SOURCE | AF 2
InPort_3158020_1 | SINK | AF 2
OutPort_3159538_1 | SOURCE | AF 2
InPort_3158935_1 | SINK | AF 2
OutPort_3158906_0 | SOURCE | AF 2
InPort_3159685_2 | SINK | AF 2
OutPort_3159608_1 | SOURCE | AF 2
InPort_3159668_1 | SINK | AF 2
OutPort_3159685_1 | SOURCE | AF 2
InPort_3159836_2 | SINK | AF 2
OutPort_3159818_0 | SOURCE | AF 2
InPort_3159818_1 | SINK | AF 2
Port_3168814_0 | SOURCEANDSINK | AF 7
Port_3168830_2 | SOURCEANDSINK | AF 7

# IfcFlowController: Valvula Borboleta - Agua Fria - MEP - Tigre:75 mm, Valvula Borboleta - Agua Fria - MEP - Tigre:75 mm:3086524
In: Térreo-COM
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: © Tigre S/A
Pset_DistributionFlowElementCommon - Reference: 75 mm; sets with these values: 2
Group: AF 30

# IfcFlowFitting: PVC Esgoto_Joelho 45_90 Aninhado_Rodrigo MEP1:a. Série Normal 2 (2)
In: Térreo-COM
Type - Material: PVC Série Normal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: a. Série Normal 2; sets with these values: 2
Name (PVC Esgoto_Joelho 45_90 Aninhado_Rodrigo MEP1:a. Série Normal 2:...)
3071346
3138211

# IfcFlowFitting: PVC Esgoto_Joelho 45_90_Rodrigo MEP:a. Série Normal (4)
In: Térreo-COM
Type - Material: PVC Série Normal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: a. Série Normal; sets with these values: 2
Name (PVC Esgoto_Joelho 45_90_Rodrigo MEP:a. Série Normal:...) | Group
3068701 | Esgoto Primário 3
3074063 | Esgoto Primário 14
3074211 | Esgoto Primário 16
3074447 | Esgoto Primário 19

# IfcFlowFitting: PVC Esgoto_Luva Simples para Conexão_Rodrigo MEP:Standard (4)
In: Térreo-COM
Type - Material: PVC Série Normal
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Standard; sets with these values: 2
Name (PVC Esgoto_Luva Simples para Conexão_Rodrigo MEP:Standard:...)
3068705
3074066
3074213
3074449

# IfcFlowFitting: PVC Marrom Soldável_Bucha de Reducão Curta_Rodrigo MEP:Bucha de Redução Curta (10)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Bucha de Redução Curta; sets with these values: 2
Name (PVC Marrom Soldável_Bucha de Reducão Curta_Rodrigo MEP:Bucha de Redução Curta:...) | Group
3082215 | AF 4
3085521 | AF 9
3091089 | AF 7
3165129 | AF 7
3165831 | AF 7
3165854 | AF 4
3165856 | AF 4
3165862 | AF 4
3165882 | AF 4
3165895 | AF 4

# IfcFlowFitting: PVC Marrom Soldável_Bucha de Reducão Longa_Rodrigo MEP:Bucha de Redução (11)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Bucha de Redução; sets with these values: 2
Name (PVC Marrom Soldável_Bucha de Reducão Longa_Rodrigo MEP:Bucha de Redução:...) | Group
3082507 | AF 4
3082874 | AF 4
3083859 | AF 4
3084643 | AF 4
3089089 | AF 8
3089593 | AF 7
3142997 | AF 8
3158935 | AF 2
3159685 | AF 2
3159836 | AF 2
3168830 | AF 7

# IfcFlowFitting: PVC Marrom Soldável_Curva 45°_90°_Rodrigo MEP:Curva (9)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Curva; sets with these values: 2
Name (PVC Marrom Soldável_Curva 45°_90°_Rodrigo MEP:Curva:...) | Group
3082346 | AF 4
3085672 | AF 27
3085676 | AF 26
3085678 | AF 21
3085680 | AF 22
3085682 | AF 19
3085684 | AF 16
3089871 | AF 7
3091130 | AF 7

# IfcFlowFitting: PVC Marrom Soldável_Joelho 45°_90°_Rodrigo MEP1:Joelho (5)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Joelho; sets with these values: 2
Name (PVC Marrom Soldável_Joelho 45°_90°_Rodrigo MEP1:Joelho:...) | Group
3080653 | AF 6
3081572 | AF 4
3082870 | AF 4
3083804 | AF 4
3088024 | AF 8

# IfcFlowFitting: PVC Marrom Soldável_Joelho 45°_90°_Rodrigo MEP:Joelho (31)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Joelho; sets with these values: 2
Name (PVC Marrom Soldável_Joelho 45°_90°_Rodrigo MEP:Joelho:...) | Group
3082342 | AF 4
3082998 | AF 4
3083529 | AF 4
3083533 | AF 4
3083760 | AF 4
3084207 | AF 4
3084211 | AF 4
3084645 | AF 4
3084725 | AF 4
3086213 | AF 11
3087815 | AF 8
3089873 | AF 7
3089936 | AF 7
3090177 | AF 7
3090421 | AF 7
3090631 | AF 7
3090635 | AF 7
3091087 | AF 7
3091113 | AF 7
3091126 | AF 7
3155909 | AF 4
3155919 | AF 4
3155983 | AF 4
3156213 | AF 4
3156333 | AF 2
3156855 | AF 2
3157376 | AF 2
3159538 | AF 2
3159543 | AF 2
3169159 | AF 11
3169543 | AF 10

# IfcFlowFitting: PVC Marrom Soldável_Joelho 90° Azul com Bucha de Latão_Rodrigo MEP:Joelho_20x1/2''_ 25x1/2''_ 25x3/4'' _ 32x3/4'' (4)
In: Térreo-COM
Type - Material: PVC Azul
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Joelho_20x1/2''_ 25x1/2''_ 25x3/4'' _ 32x3/4''; sets with these values: 2
Name (PVC Marrom Soldável_Joelho 90° Azul com Bucha de Latão_Rodrigo MEP:Joelho_20x1/2''_ 25x1/2''_ 25x3/4'' _ 32x3/4'':...) | Group
3156249 | AF 4
3156329 | AF 2
3156851 | AF 2
3159524 | AF 2

# IfcFlowFitting: PVC Marrom Soldável_Tê e Tê de Reducão_Rodrigo MEP1:Tê (2)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Tê; sets with these values: 2
Group: AF 4
Name (PVC Marrom Soldável_Tê e Tê de Reducão_Rodrigo MEP1:Tê:...)
3080677
3080715

# IfcFlowFitting: PVC Marrom Soldável_Tê e Tê de Reducão_Rodrigo MEP:Tê (20)
In: Térreo-COM
Type - Material: PVC Marrom
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: Tê; sets with these values: 2
Name (PVC Marrom Soldável_Tê e Tê de Reducão_Rodrigo MEP:Tê:...) | Group
3080655 | AF 9
3081562 | AF 4
3082250 | AF 4
3082537 | AF 4
3083500 | AF 4
3083752 | AF 4
3083936 | AF 4
3085744 | AF 11
3087669 | AF 8
3087860 | AF 8
3089047 | AF 8
3089273 | AF 7
3089826 | AF 7
3090413 | AF 7
3090586 | AF 7
3090925 | AF 7
3155748 | AF 4
3156313 | AF 2
3156835 | AF 2
3157356 | AF 7

# IfcFlowSegment: Tipos de tubos:PVC Esgoto Série Normal (33)
In: Térreo-COM
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: PVC Esgoto Série Normal; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:PVC Esgoto Série Normal:...) | Length (m) | Group
3068398 | 7.35879 | Esgoto Primário 1
3068659 | 4.72061 | Esgoto Primário 2
3068675 | 0.996879 | Esgoto Primário 3
3068684 | 1.57149 | Esgoto Primário 3
3068850 | 3.94136 | Esgoto Primário 4
3069098 | 8.27182 | Esgoto Primário 6
3069944 | 0.562118 | Esgoto Primário 7
3069958 | 0.56212 | Esgoto Primário 8
3070050 | 0.68184 | Esgoto Primário 9
3070066 | 0.681838 | Esgoto Primário 10
3071110 | 11.6002 | Esgoto Primário 11
3071277 | 11.2003 | Esgoto Primário 12
3073941 | 2.9048 | Esgoto Primário 13
3074030 | 0.73988 | Esgoto Primário 14
3074047 | 0.295977 | Esgoto Primário 14
3074156 | 9.58712 | Esgoto Primário 15
3074196 | 0.487593 | Esgoto Primário 16
3074205 | 0.802293 | Esgoto Primário 16
3074331 | 2.9054 | Esgoto Primário 17
3074432 | 0.769487 | Esgoto Primário 19
3074441 | 0.275835 | Esgoto Primário 19
3074550 | 0.406032 | Esgoto Primário 20
3074681 | 0.406032 | Esgoto Primário 21
3074736 | 0.406032 | Esgoto Primário 22
3074851 | 0.406032 | Esgoto Primário 23
3091509 | 11.6006 | Esgoto Primário 24
3111870 | 0.80004 | Esgoto Primário 26
3111946 | 2.38 | Esgoto Primário 25
3132036 | 4.22021 | Esgoto Primário 27
3132115 | 2.55816 | Esgoto Primário 18
3132394 | 1.97 | Esgoto Primário 28
3138146 | 4.8 | Esgoto Primário 29
3141387 | 12.12 | Esgoto Primário 30

# IfcFlowSegment: Tipos de tubos:PVC Marrom Soldável (105)
In: Térreo-COM
Type - Pset_ManufacturerTypeInformation - Manufacturer: Tigre
Pset_DistributionFlowElementCommon - Reference: PVC Marrom Soldável; sets with these values: 2
Pset_FlowSegmentDuctSegment - sets with these values: 2
Name (Tipos de tubos:PVC Marrom Soldável:...) | Length (m) | Group
3080617 | 1.56951 | AF 4
3080619 | 0.1654 | AF 4
3080623 | 1.24636 | AF 14
3080649 | 1.43453 | AF 9
3080651 | 0.18337 | AF 5
3080656 | 0.792329 | AF 15
3080661 | 2.74674 | AF 4
3080678 | 11.0195 | AF 4
3080681 | 0.988016 | AF 4
3080683 | 0.1672 | AF 3
3080687 | 0.82923 | AF 4
3080689 | 0.1846 | AF 4
3080692 | 2.55342 | AF 4
3080709 | 0.1846 | AF 4
3080716 | 2.45891 | AF 4
3080759 | 0.1263 | AF 7
3080761 | 0.7805 | AF 7
3080767 | 0.7623 | AF 7
3080773 | 0.7709 | AF 7
3080777 | 0.0083 | AF 7
3080779 | 1.17381 | AF 7
3080781 | 0.7846 | AF 7
3080789 | 1.6501 | AF 7
3080791 | 0.7846 | AF 7
3080805 | 0.7654 | AF 8
3080813 | 1.52459 | AF 8
3080817 | 0.7805 | AF 8
3081384 | 3.67924 | AF 18
3081397 | 34.4182 | AF 20
3081405 | 2.20411 | AF 24
3081415 | 5.40466 | AF 25
3081423 | 6.73503 | AF 7
3081563 | 1.75491 | AF 4
3081716 | 1.0249 | AF 4
3081894 | 0.00675642 | AF 4
3082251 | 0.00340861 | AF 4
3082280 | 0.1709 | AF 4
3082325 | 1.23033 | AF 4
3082333 | 1.45118 | AF 4
3082361 | 0.972787 | AF 4
3082538 | 3.34384 | AF 4
3082910 | 0.1805 | AF 4
3083372 | 0.1805 | AF 4
3083383 | 0.1709 | AF 4
3083501 | 2.54112 | AF 4
3083511 | 1.2871 | AF 4
3083519 | 1.7346 | AF 4
3083549 | 0.960701 | AF 4
3083753 | 3.72232 | AF 4
3083937 | 1.6968 | AF 4
3084004 | 0.1623 | AF 4
3084183 | 2.22531 | AF 4
3084196 | 0.674697 | AF 4
3084316 | 0.0046 | AF 4
3085465 | 0.00745 | AF 9
3085745 | 3.49499 | AF 17
3086186 | 1.5109 | AF 11
3086196 | 0.2246 | AF 11
3086207 | 0.6524 | AF 10
3086217 | 3.3359 | AF 29
3086728 | 1.64877 | AF 10
3087594 | 3.60375 | AF 8
3087670 | 3.62682 | AF 28
3087803 | 1.08864 | AF 8
3087840 | 0.0057 | AF 8
3087876 | 0.0905 | AF 8
3088993 | 0.70655 | AF 8
3089048 | 1.20664 | AF 8
3089274 | 4.51317 | AF 7
3089330 | 0.152776 | AF 7
3089827 | 3.37621 | AF 7
3090327 | 0.36305 | AF 7
3090414 | 0.911757 | AF 7
3090587 | 1.86946 | AF 7
3090615 | 0.894492 | AF 7
3090623 | 0.277417 | AF 7
3090696 | 0.986288 | AF 7
3090926 | 2.30829 | AF 7
3091028 | 0.7831 | AF 7
3091102 | 0.4482 | AF 7
3091115 | 0.57577 | AF 7
3155734 | 0.8901 | AF 4
3155749 | 0.529404 | AF 4
3155899 | 6.3292 | AF 4
3155911 | 2.0492 | AF 4
3155921 | 0.293512 | AF 4
3156236 | 0.4693 | AF 4
3156314 | 1.70138 | AF 13
3156325 | 0.0255 | AF 2
3156326 | 0.4693 | AF 2
3156827 | 0.198593 | AF 2
3156836 | 1.15322 | AF 23
3156847 | 0.0255 | AF 2
3156848 | 0.4693 | AF 2
3157348 | 6.2417 | AF 2
3157357 | 0.398453 | AF 7
3157364 | 5.14902 | AF 2
3158003 | 0.0684677 | AF 2
3158019 | 0.00949993 | AF 2
3158020 | 0.468099 | AF 2
3158906 | 0.054 | AF 2
3159608 | 0.1076 | AF 2
3159668 | 0.454215 | AF 2
3159818 | 0.1302 | AF 2
3168814 | 0.0293 | AF 7

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60cm - CI (2)
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60cm - CI; sets with these values: 2
Name (Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60cm - CI:...)
3056670
3056675 | Group: Esgoto Primário 5

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x40cm - CI (2)
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x40cm - CI; sets with these values: 2
Name (Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x40cm - CI:...)
3056650
3056655

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x45cm - CI, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x45cm - CI:3056660
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x45cm - CI; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x50cm - CI, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x50cm - CI:3056645
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x50cm - CI; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x55cm - CI (2)
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x55cm - CI; sets with these values: 2
Name (Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x55cm - CI:...)
3056640
3056665

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x65cm - CI 2, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x65cm - CI 2:3131679
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x65cm - CI 2; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x70cm - CI 2, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x70cm - CI 2:3132259
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x70cm - CI 2; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x75cm - CI 2, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x75cm - CI 2:3071190
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x75cm - CI 2; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x85cm - CI 2, Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x85cm - CI 2:3091416
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x85cm - CI 2; sets with these values: 2

# IfcFlowTerminal: Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x95cm - CI 2 (2)
In: Térreo-COM
Type - Material: <Unnamed>, Tijolo, Comum, .CONCRETO
Type - Pset_ManufacturerTypeInformation - Manufacturer: -
Pset_DistributionFlowElementCommon - Reference: 60x60x95cm - CI 2; sets with these values: 2
Name (Caixa de Inspeção em Alvenaria_Rodrigo MEP:60x60x95cm - CI 2:...)
3092257
3137901

# IfcFlowTerminal: Reservatório de Água Tipo Taça:a3. 10000L Coluna Cheia, Reservatório de Água Tipo Taça:a3. 10000L Coluna Cheia:3066954
In: Térreo-COM
Type - Material: GUARDA CORPO TORRE, Concreto, TORRE
Type - Pset_ManufacturerTypeInformation - Manufacturer: AME Reservatórios Metálicos
Pset_DistributionFlowElementCommon - Reference: a3. 10000L Coluna Cheia; sets with these values: 2

# IfcFlowTerminal: Sumidouro_Rodrigo MEP:Sumidouro (2)
In: Térreo-COM
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Não Listar
Pset_DistributionFlowElementCommon - Reference: Sumidouro; sets with these values: 2
Name (Sumidouro_Rodrigo MEP:Sumidouro:...)
3071338
3138203

# IfcFlowTerminal: Torneira de Jardim:Torneira de Jardim, 25mm x Ø3/4'' (4)
In: Térreo-COM
Type - Material: <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Deca
Pset_DistributionFlowElementCommon - Reference: Torneira de Jardim, 25mm x Ø3/4''; sets with these values: 2
Name (Torneira de Jardim:Torneira de Jardim, 25mm x Ø3/4'':...) | Group
3155630 | AF 1
3155640 | AF 2
3155661 | AF 2
3155666 | AF 2
